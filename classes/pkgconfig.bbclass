PKGCONFIG_DEPENDS = "pkg-config-native"
DEPENDS_prepend += "${PKGCONFIG_DEPENDS}"
