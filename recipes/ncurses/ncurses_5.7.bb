require ncurses.inc

SRC_URI = "${GNU_MIRROR}/ncurses/ncurses-${PV}.tar.gz"
S = "${WORKDIR}/ncurses-${PV}"
