DESCRIPTION = "Create update image with images."
LICENSE = "GPLv2"
PR = "r5"

inherit dupdate_images

RDEPENDS = "\
deif-os-rootfs \
deif-os-kernel \
dupdate-update \
"
