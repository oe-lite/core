DESCRIPTION = "Create update image with images."
LICENSE = "GPLv2"
PR = "r5"

inherit dupdate_images

RDEPENDS = "\
deif-hwtest-kernel \
dupdate-update \
"
