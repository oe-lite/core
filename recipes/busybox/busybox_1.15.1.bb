require busybox.inc

PR = "r1${INC_PR}"

#SRC_URI_append = "\
#  file://B921600.patch;patch=1 \
#  file://get_header_tar.patch;patch=1 \
#  file://busybox-appletlib-dependency.patch;patch=1 \
#"
