inherit files

DEPENDS = "busybox dropbear busybox mtd-utils netbase dupdate "
RDEPENDS = "busybox ssh sshd busybox-inetd mtd-utils netbase dupdate "
#DEPENDS = "busybox"
