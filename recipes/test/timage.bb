inherit ubifs_images

RDEPENDS = "test"
