require deif-os-u-boot_${PV}.bb
require u-boot-deif-hwtest.inc
