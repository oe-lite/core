require ${BPN}.inc
inherit cross
