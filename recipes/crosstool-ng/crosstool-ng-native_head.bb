require ${PN}.inc

SRC_URI = "hg://ymorin.is-a-geek.org/hg/;module=crosstool-ng;rev=default"

S = "${SRCDIR}/${BPN}"

DEFAULT_PREFERENCE = "-1"
