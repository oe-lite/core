require ${PN}.inc
SRC_URI = "hg://ymorin.is-a-geek.org/hg/;module=crosstool-ng;rev=default"
PR = "r1${INC_PR}"
