require ${BPN}.inc
inherit sdk-cross
