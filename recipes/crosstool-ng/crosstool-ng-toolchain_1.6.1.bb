require ${BPN}.inc
BBCLASSEXTEND="cross sdk-cross canadian-cross"
