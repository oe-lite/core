require crosstool-ng.inc
PR = "r1${INC_PR}"
SRC_URI = "file://crosstool-ng-test.tar.gz file://defconfig.${TARGET_SYS}"
#S = "${WORKDIR}/crosstool-ng-test"
