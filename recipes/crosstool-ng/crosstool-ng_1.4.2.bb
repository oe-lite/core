require crosstool-ng.inc
PR = "r1${INC_PR}"
SRC_URI = "hg://ymorin.is-a-geek.org/hg/;module=crosstool-ng;rev=crosstool-ng-${PV}"
