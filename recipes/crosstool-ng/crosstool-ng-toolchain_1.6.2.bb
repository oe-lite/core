require ${BPN}.inc
BBCLASSEXTEND="cross sdk-cross canadian-cross"
DEFAULT_PREFERENCE = "-1"