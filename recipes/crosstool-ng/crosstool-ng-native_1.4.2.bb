require crosstool-ng-native.inc
SRC_URI = "http://ymorin.is-a-geek.org/download/crosstool-ng/crosstool-ng-${PV}.tar.bz2"
S = "${WORKDIR}/${BPN}-${PV}"
